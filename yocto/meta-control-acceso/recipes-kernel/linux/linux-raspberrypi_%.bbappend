FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"
SRC_URI += "file://codec.cfg"
